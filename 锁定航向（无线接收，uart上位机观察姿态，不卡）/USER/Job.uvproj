# Keil uVision project Job.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Job +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\MPU6050;..\USER;..\HARDWARE\IMU;..\HARDWARE\FAST_MATH;..\HARDWARE\CONTROL;..\HARDWARE\HMC5883
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MPU6050/: MPU6050.c STM32_I2C.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/FAST_MATH/: fast_math.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/HMC5883/: HMC5883.c
